<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bw</value></param>
<param><key>value</key><value>96000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>433920000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>blks2_tcp_sink</key>
<param><key>id</key><value>blks2_tcp_sink_0</value></param>
<param><key>addr</key><value>127.0.0.1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>server</key><value>True</value></param>
<param><key>port</key><value>1337</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>fcd_source_c</key>
<param><key>id</key><value>fcd_source_c_0</value></param>
<param><key>dci</key><value>0.0</value></param>
<param><key>dcq</key><value>0.0</value></param>
<param><key>device_name</key><value>hw:1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>freq</value></param>
<param><key>ppm</key><value>-120</value></param>
<param><key>iq_gain</key><value>1.0</value></param>
<param><key>iq_phase</key><value>0.0</value></param>
<param><key>lna</key><value>gain</value></param>
<param><key>mixer</key><value>+12</value></param>
</block>
<block>
<key>fcdproplus_fcdproplus</key>
<param><key>id</key><value>fcdproplus_fcdproplus_0</value></param>
<param><key>device_name</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>freq</value></param>
<param><key>ppm</key><value>0</value></param>
<param><key>if_gain</key><value>gain</value></param>
<param><key>lnaswitch</key><value>1</value></param>
<param><key>mixergainswitch</key><value>1</value></param>
<param><key>unit</key><value>1</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>gain</value></param>
<param><key>bw0</key><value>bw</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>gain</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<connection><source_block_id>fcd_source_c_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fcdproplus_fcdproplus_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blks2_tcp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
