options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: top_block
    output_language: python
    run_options: run
  states: {}

blocks:
- name: antenna_index
  id: variable
  parameters:
    value: '0'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: bb_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: channel_index
  id: variable
  parameters:
    value: '0'
  states: {}
- name: direct_sampling_mode
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq_correction
  id: variable
  parameters:
    value: '0'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: port
  id: variable
  parameters:
    value: '1234'
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 3e6
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: port
    psize: '65536'
    type: complex
    vlen: '1'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: bladerf
    bb_gain0: bb_gain
    bw0: bandwidth
    corr0: freq_correction
    freq0: frequency
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: sample_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_udp_source_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
